# IAR project Nonsecure.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG_PORT=UART1_NS
  ICCARM.CCIncludePath2: ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Device\Nuvoton\M2351\Include; ..\..\..\..\..\Library\StdDriver\inc; ..; ..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Nonsecure.bin
  ILINK.IlinkOutputFile: Nonsecure.out
  ILINK.IlinkIcfFile: m2351_ns.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../../Library/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../../../../Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Library
    ../../Secure/IAR/Release/Exe/: nsclib_IAR.o
    ../../../../../Library/StdDriver/src/: gpio.c retarget.c uart.c
  group User
    ../: main_Nonsecure.c
